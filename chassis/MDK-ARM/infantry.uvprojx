# Keil uVision project infantry.uvprojx, settings and files
target infantry (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\APP\pid;..\BSP\bsp_can;..\APP\chassis_move;..\Core\Inc;..\APP\chassis_task;..\APP\remote_control;..\BSP\bsp_referee;..\APP\referee;..\components\support;..\APP\struct_typedef;..\APP\protocol;..\APP\fuzzy_pid;..\APP\supercap;..\APP\lqr;..\APP\imu;..\BSP\BSP_BUZZER;..\BSP\BSP_FLASH;..\BSP\BSP_IMU;..\BSP\BSP_MATH;..\BSP\BSP_SPI;..\BSP\BSP_TIM;..\TASK;..\components\algorithm;..\components\devices;..\APP\led;..\APP\MY_anonymous;..\APP\Kinematics;..\APP\referee_UI;..\BSP\BSP_UART;..\Drivers\CMSIS\DSP\Include;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: my_init.c main.c gpio.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group APP
    ../APP/pid/: pid.c
    ../APP/chassis_move/: chassis_move.c
    ../APP/chassis_task/: chassis_task.c
    ../APP/remote_control/: remote_control.c
    ../APP/referee/: referee.c
    ../APP/supercap/: supercap.c
    ../APP/imu/: imu.c
    ../APP/led/: led.c
    ../APP/MY_anonymous/: MY_anonymous.c
    ../APP/Kinematics/: kinematics.c
    ../APP/lqr/: lqr.c
    ../APP/line_fit/: line_fit.c
    ../APP/referee_UI/: referee_UI.c
    ../APP/: offline_check.c
  group BSP
    ../BSP/bsp_can/: bsp_can.c
    ../BSP/bsp_referee/: bsp_referee.c
    ../BSP/BSP_BUZZER/: bsp_buzzer.c
    ../BSP/BSP_FLASH/: bsp_flash.c
    ../BSP/BSP_IMU/: bsp_imu.c bsp_imu_pwm.c
    ../BSP/BSP_TIM/: delay.c
    ../BSP/BSP_MATH/: bsp_math.c
    ../BSP/BSP_SPI/: bsp_spi.c
    ../BSP/BSP_UART/: bsp_uart.c
  group TASK
    ../TASK/: calibrate_task.c
  group driver
    ../components/devices/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group Algorithm
    ../components/algorithm/: MahonyAHRS.c user_lib.c
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group components
    ../components/support/: fifo.c CRC8_CRC16.c
software components: CMSIS:CORE 5.6.0
