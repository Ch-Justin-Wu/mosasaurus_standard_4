# Keil uVision project gimbal.uvprojx, settings and files
target gimbal (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gimbal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../APP;../BSP/BSP_CAN;../BSP/BSP_TIM;../Core/Src;../BSP/BSP_IMU;../components/algorithm;../components/devices;../BSP/BSP_SPI;../BSP/BSP_FLASH;../BSP/BSP_BUZZER;../BSP/BSP_UART;../BSP/BSP_MATH;../TASK;../components/support;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../BSP/BSP_USB;../Comunication;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/Source/FastMathFunctions
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group APP
    ../APP/: imu.c can_receive.c led.c pid.c remote_control.c blueteeth.c referee.c buzzer.c
    ../TASK/: RC_task.c
    ../Comunication/: Self_aim.c USB_Commucation.c
  group BSP
    ../BSP/BSP_CAN/: bsp_can.c
    ../BSP/BSP_TIM/: delay.c
    ../BSP/BSP_SPI/: bsp_spi.c
    ../BSP/BSP_IMU/: bsp_imu.c bsp_imu_pwm.c
    ../BSP/BSP_FLASH/: bsp_flash.c
    ../BSP/BSP_BUZZER/: bsp_buzzer.c buzzer_bsp.c
    ../BSP/BSP_UART/: bsp_uart.c bsp_referee_uart.c
    ../BSP/BSP_MATH/: bsp_math.c
    ../BSP/BSP_USB/: bsp_usb.c
  group TASK
    ../TASK/: chassis_task.c gimbal_task.c gimbal_task_behaviour.c Sent_Task.c TIM3_cnt_task.c vision_task.c shoot_task.c calibrate_task.c upper_computer.c
  group Algorithm
    ../components/algorithm/: MahonyAHRS.c user_lib.c
  group components
    ../components/support/: CRC8_CRC16.c fifo.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_atan2_f32.c arm_cos_f32.c arm_sin_f32.c
  group devices
    ../components/devices/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
